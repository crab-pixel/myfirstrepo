VERSION 5.8 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO vihaan_pingalkar
  CLASS BLOCK ;
  FOREIGN vihaan_pingalkar 0 0 ;
  ORIGIN 0 0 ;
  SIZE 76.800 BY 8.800 ;
  SYMMETRY X Y ;
  # The GDS artwork uses Metal5.  Reserve that layer across the macro so
  # signal routing cannot overlap the decorative geometry.
  OBS
    LAYER Metal5 ;
      RECT 0.000 0.000 76.800 8.800 ;
  END
END vihaan_pingalkar

END LIBRARY
